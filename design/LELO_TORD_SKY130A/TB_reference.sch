v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 340 320 380 320 {lab=VSS}
N 340 440 380 440 {lab=B5}
N 340 420 380 420 {lab=B4}
N 340 400 380 400 {lab=B3}
N 340 380 380 380 {lab=B2}
N 340 360 380 360 {lab=B1}
N 340 260 380 260 {lab=VDD}
N 340 280 380 280 {lab=SLP}
N 340 340 380 340 {lab=BT}
N 340 500 380 500 {lab=B8}
N 340 480 380 480 {lab=B7}
N 340 460 380 460 {lab=B6}
N 1100 240 1100 300 {lab=IOUT}
N 1540 780 1540 840 {lab=V2C}
N 1500 740 1520 740 {lab=VSS}
N 1500 740 1500 940 {lab=VSS}
N 750 940 2040 940 {lab=VSS}
N 1100 900 1100 940 {lab=VSS}
N 1040 870 1060 870 {lab=VSS}
N 1040 870 1040 940 {lab=VSS}
N 1540 900 1540 940 {lab=VSS}
N 1580 870 1600 870 {lab=VSS}
N 1600 870 1600 940 {lab=VSS}
N 1540 400 1540 550 {lab=V2A}
N 1240 560 1280 560 {lab=V1B}
N 1020 380 1060 380 {lab=VDD}
N 1020 350 1060 350 {lab=SWBRN1}
N 1590 380 1630 380 {lab=VSS}
N 1460 380 1500 380 {lab=VDD}
N 1460 350 1500 350 {lab=SWBRN2}
N 1720 770 1720 940 {lab=VSS}
N 1720 560 1720 700 {lab=V2}
N 1540 240 1540 300 {lab=IOUT}
N 1100 400 1100 550 {lab=V1A}
N 920 770 920 940 {lab=VSS}
N 1100 570 1100 840 {lab=V1A}
N 1280 560 1280 700 {lab=V1B}
N 1280 780 1280 820 {lab=R1}
N 1280 900 1280 940 {lab=VSS}
N 1240 740 1260 740 {lab=VSS}
N 1240 740 1240 940 {lab=VSS}
N 1240 860 1260 860 {lab=VSS}
N 1360 780 1360 820 {lab=R2}
N 1380 740 1400 740 {lab=VSS}
N 1400 740 1400 940 {lab=VSS}
N 1380 860 1400 860 {lab=VSS}
N 1360 900 1360 940 {lab=VSS}
N 1660 610 1660 650 {lab=VSS}
N 1660 480 1660 520 {lab=VDD}
N 1630 480 1630 520 {lab=SWCAP2}
N 1680 560 1720 560 {lab=V2}
N 920 560 920 700 {lab=V1}
N 980 610 980 650 {lab=VSS}
N 980 480 980 520 {lab=VDD}
N 1010 480 1010 520 {lab=SWCAP1}
N 1540 570 1540 700 {lab=V2A}
N 1090 550 1090 570 {lab=V1A}
N 1090 570 1110 570 {lab=V1A}
N 1110 550 1110 570 {lab=V1A}
N 1090 550 1110 550 {lab=V1A}
N 1530 550 1530 570 {lab=V2A}
N 1530 570 1550 570 {lab=V2A}
N 1550 550 1550 570 {lab=V2A}
N 1530 550 1550 550 {lab=V2A}
N 1220 610 1220 650 {lab=VSS}
N 1220 480 1220 520 {lab=VDD}
N 1190 480 1190 520 {lab=SWBGR1}
N 1420 610 1420 650 {lab=VSS}
N 1420 480 1420 520 {lab=VDD}
N 1450 480 1450 520 {lab=SWBGR2}
N 1360 560 1400 560 {lab=V2B}
N 1360 560 1360 700 {lab=V2B}
N 1150 380 1190 380 {lab=VSS}
N 1840 560 1840 700 {lab=V2}
N 1840 760 1840 940 {lab=VSS}
N 760 560 960 560 {lab=V1}
N 800 560 800 700 {lab=V1}
N 800 760 800 940 {lab=VSS}
N 720 730 760 730 {lab=SWDRN1}
N 800 730 840 730 {lab=VSS}
N 840 730 840 780 {lab=VSS}
N 800 780 840 780 {lab=VSS}
N 1800 730 1840 730 {lab=VSS}
N 1800 730 1800 780 {lab=VSS}
N 1800 780 1840 780 {lab=VSS}
N 1880 730 1920 730 {lab=SWDRN2}
N 1060 560 1090 560 {lab=V1A}
N 1110 560 1140 560 {lab=V1A}
N 1500 560 1530 560 {lab=V2A}
N 1550 560 1580 560 {lab=V2A}
N 1840 560 1880 560 {lab=V2}
N 1840 540 1880 540 {lab=V1}
N 1720 560 1840 560 {lab=V2}
N 340 680 380 680 {lab=SWBRN1}
N 340 700 380 700 {lab=SWBRN2}
N 340 750 380 750 {lab=SWCAP1}
N 340 770 380 770 {lab=SWCAP2}
N 340 820 380 820 {lab=SWBGR1}
N 340 840 380 840 {lab=SWBGR2}
N 340 870 380 870 {lab=SWDRN1}
N 340 890 380 890 {lab=SWDRN2}
N 2090 380 2130 380 {lab=VSS}
N 1960 380 2000 380 {lab=VDD}
N 1960 350 2000 350 {lab=SWBRN3}
N 2220 770 2220 940 {lab=VSS}
N 2360 760 2360 940 {lab=VSS}
N 2360 560 2360 700 {lab=VOUT}
N 2320 730 2360 730 {lab=VSS}
N 2320 730 2320 780 {lab=VSS}
N 2320 780 2360 780 {lab=VSS}
N 2220 940 2360 940 {lab=VSS}
N 2400 730 2440 730 {lab=SWDRN3}
N 2040 240 2040 300 {lab=IOUT}
N 2040 400 2040 700 {lab=VREF}
N 2000 740 2020 740 {lab=VSS}
N 2000 740 2000 940 {lab=VSS}
N 2040 780 2040 940 {lab=VSS}
N 2040 940 2220 940 {lab=VSS}
N 2220 560 2220 700 {lab=VOUT}
N 2160 610 2160 650 {lab=VSS}
N 2160 480 2160 520 {lab=VDD}
N 2130 480 2130 520 {lab=SWCAP3}
N 2180 560 2220 560 {lab=VOUT}
N 2040 560 2080 560 {lab=VREF}
N 2220 560 2360 560 {lab=VOUT}
N 2360 560 2400 560 {lab=VOUT}
N 340 910 380 910 {lab=SWDRN3}
N 340 790 380 790 {lab=SWCAP3}
N 340 720 380 720 {lab=SWBRN3}
N 340 580 380 580 {lab=B12}
N 340 560 380 560 {lab=B11}
N 340 540 380 540 {lab=B10}
N 340 520 380 520 {lab=B9}
N 340 640 380 640 {lab=B15}
N 340 620 380 620 {lab=B14}
N 340 600 380 600 {lab=B13}
N 2200 280 2240 280 {lab=V2}
N 2200 300 2240 300 {lab=V1}
N 2540 260 2580 260 {lab=CMP_ASYNC}
N 2200 360 2240 360 {lab=VSS}
N 2200 260 2240 260 {lab=VDD}
N 680 260 720 260 {lab=IOUT}
N 340 300 380 300 {lab=SLP_N}
N 590 790 630 790 {lab=SLP_N}
N 550 750 590 750 {lab=VDD}
N 550 830 590 830 {lab=VSS}
N 470 790 510 790 {lab=SLP}
N 2200 320 2240 320 {lab=SLP}
N 2200 340 2240 340 {lab=SLP_N}
C {devices/ipin.sym} 340 360 0 0 {name=p17 lab=B1}
C {devices/ipin.sym} 340 380 0 0 {name=p18 lab=B2}
C {devices/ipin.sym} 340 400 0 0 {name=p19 lab=B3}
C {devices/ipin.sym} 340 420 0 0 {name=p20 lab=B4}
C {devices/ipin.sym} 340 320 0 0 {name=p1 lab=VSS}
C {devices/ipin.sym} 340 260 0 0 {name=p2 lab=VDD}
C {devices/ipin.sym} 340 280 0 0 {name=p3 lab=SLP}
C {devices/ipin.sym} 340 340 0 0 {name=p4 lab=B0}
C {devices/ipin.sym} 340 440 0 0 {name=p5 lab=B5}
C {devices/ipin.sym} 340 460 0 0 {name=p6 lab=B6}
C {devices/ipin.sym} 340 480 0 0 {name=p8 lab=B7}
C {sky130_fd_pr/pnp_05v5.sym} 1080 870 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 1560 870 0 1 {name=Q2[7:0]
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1100 290 3 1 {name=x3}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1540 290 3 1 {name=x4}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 1720 760 0 1 {name=x16[9:0]
}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 920 760 0 0 {name=x10[9:0]
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1570 560 0 0 {name=x8}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1070 560 0 1 {name=x5}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1130 560 0 0 {name=x6}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1510 560 0 1 {name=x7}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 760 730 0 0 {name=x9}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1880 730 0 1 {name=x17}
C {devices/lab_wire.sym} 980 640 0 0 {name=p44 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 980 510 0 0 {name=p45 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1050 350 0 0 {name=p46 sig_type=std_logic lab=SWBRN1}
C {devices/lab_wire.sym} 1050 380 0 0 {name=p47 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 380 0 1 {name=p48 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1220 510 0 1 {name=p49 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1220 640 0 1 {name=p50 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1010 510 0 1 {name=p51 sig_type=std_logic lab=SWCAP1}
C {devices/lab_wire.sym} 1190 510 0 0 {name=p52 sig_type=std_logic lab=SWBGR1}
C {devices/lab_wire.sym} 1450 510 0 1 {name=p53 sig_type=std_logic lab=SWBGR2}
C {devices/lab_wire.sym} 1630 510 0 0 {name=p55 sig_type=std_logic lab=SWCAP2}
C {devices/lab_wire.sym} 1420 510 0 0 {name=p56 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 510 0 1 {name=p57 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1420 640 0 0 {name=p58 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1660 640 0 1 {name=p59 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1600 380 0 1 {name=p60 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1490 350 0 0 {name=p61 sig_type=std_logic lab=SWBRN2}
C {devices/lab_wire.sym} 1490 380 0 0 {name=p62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 750 730 0 0 {name=p64 sig_type=std_logic lab=SWDRN1}
C {devices/lab_wire.sym} 1890 730 0 1 {name=p65 sig_type=std_logic lab=SWDRN2}
C {devices/lab_wire.sym} 1110 570 2 0 {name=p66 sig_type=std_logic lab=V1A}
C {devices/lab_wire.sym} 1280 570 2 0 {name=p67 sig_type=std_logic lab=V1B}
C {devices/lab_wire.sym} 1360 570 2 1 {name=p68 sig_type=std_logic lab=V2B}
C {devices/lab_wire.sym} 1530 570 2 1 {name=p69 sig_type=std_logic lab=V2A}
C {devices/lab_wire.sym} 1540 820 0 0 {name=p70 sig_type=std_logic lab=V2C}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 1360 820 3 1 {name=x14[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 1280 820 1 0 {name=x12[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 1540 780 1 1 {name=x15[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 1280 700 1 0 {name=x11[1:0] }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 1360 700 3 1 {name=x13[1:0]}
C {devices/lab_pin.sym} 760 560 0 0 {name=p75 sig_type=std_logic lab=V1}
C {devices/lab_wire.sym} 1280 810 0 0 {name=p71 sig_type=std_logic lab=R1}
C {devices/lab_wire.sym} 1360 810 0 1 {name=p80 sig_type=std_logic lab=R2}
C {devices/opin.sym} 1880 560 0 0 {name=p21 lab=V2}
C {devices/opin.sym} 1880 540 2 1 {name=p26 lab=V1}
C {devices/ipin.sym} 340 870 0 0 {name=p27 lab=SWDRN1}
C {devices/ipin.sym} 340 680 0 0 {name=p28 lab=SWBRN1}
C {devices/ipin.sym} 340 700 0 0 {name=p29 lab=SWBRN2}
C {devices/ipin.sym} 340 750 0 0 {name=p30 lab=SWCAP1}
C {devices/ipin.sym} 340 770 0 0 {name=p31 lab=SWCAP2}
C {devices/ipin.sym} 340 820 0 0 {name=p32 lab=SWBGR1}
C {devices/ipin.sym} 340 840 0 0 {name=p33 lab=SWBGR2}
C {devices/ipin.sym} 340 890 0 0 {name=p34 lab=SWDRN2}
C {devices/lab_wire.sym} 790 940 0 0 {name=p35 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 690 260 0 1 {name=p12 sig_type=std_logic lab=IOUT}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2040 290 3 1 {name=x18}
C {devices/lab_wire.sym} 2100 380 0 1 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1990 350 0 0 {name=p16 sig_type=std_logic lab=SWBRN3}
C {devices/lab_wire.sym} 1990 380 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 2220 760 0 1 {name=x21[11:0]}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 2400 730 0 1 {name=x22 }
C {devices/lab_wire.sym} 2420 730 0 1 {name=p23 sig_type=std_logic lab=SWDRN3}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 2040 700 1 0 {name=x20[1:0]}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2070 560 0 0 {name=x19}
C {devices/lab_wire.sym} 2130 510 0 0 {name=p24 sig_type=std_logic lab=SWCAP3}
C {devices/lab_wire.sym} 2160 510 0 1 {name=p25 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2160 640 0 1 {name=p36 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 2400 560 2 1 {name=p37 lab=VOUT}
C {devices/lab_wire.sym} 2040 570 0 0 {name=p38 sig_type=std_logic lab=VREF}
C {devices/ipin.sym} 340 910 0 0 {name=p39 lab=SWDRN3}
C {devices/ipin.sym} 340 790 0 0 {name=p40 lab=SWCAP3}
C {devices/ipin.sym} 340 720 0 0 {name=p42 lab=SWBRN3}
C {LELO_TORD_SKY130A/dac_v4.sym} 530 450 0 0 {name=x1}
C {devices/ipin.sym} 340 500 0 0 {name=p54 lab=B8}
C {devices/ipin.sym} 340 520 0 0 {name=p63 lab=B9}
C {devices/ipin.sym} 340 540 0 0 {name=p72 lab=B10}
C {devices/ipin.sym} 340 560 0 0 {name=p73 lab=B11}
C {devices/ipin.sym} 340 580 0 0 {name=p74 lab=B12}
C {devices/ipin.sym} 340 600 0 0 {name=p76 lab=B13}
C {devices/ipin.sym} 340 620 0 0 {name=p77 lab=B14}
C {devices/ipin.sym} 340 640 0 0 {name=p7 lab=B15}
C {devices/lab_wire.sym} 2230 260 0 0 {name=p78 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2230 300 0 0 {name=p79 sig_type=std_logic lab=V1}
C {devices/lab_wire.sym} 2230 280 0 0 {name=p81 sig_type=std_logic lab=V2}
C {devices/lab_wire.sym} 2230 360 0 0 {name=p82 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 2580 260 2 1 {name=p83 lab=CMP_ASYNC}
C {LELO_TORD_SKY130A/cmp.sym} 2390 310 0 0 {name=x2}
C {devices/lab_wire.sym} 1100 260 0 1 {name=p9 sig_type=std_logic lab=IOUT}
C {devices/lab_wire.sym} 1540 260 0 1 {name=p10 sig_type=std_logic lab=IOUT}
C {devices/lab_wire.sym} 2040 260 0 1 {name=p11 sig_type=std_logic lab=IOUT}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 510 790 0 0 {name=x10 }
C {devices/lab_wire.sym} 500 790 0 0 {name=p14 sig_type=std_logic lab=SLP}
C {devices/lab_wire.sym} 600 790 0 1 {name=p41 sig_type=std_logic lab=SLP_N}
C {devices/lab_wire.sym} 560 750 0 1 {name=p43 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 560 830 2 0 {name=p84 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 340 300 0 0 {name=p13 sig_type=std_logic lab=SLP_N}
C {devices/lab_wire.sym} 2230 340 0 0 {name=p85 sig_type=std_logic lab=SLP_N}
C {devices/lab_wire.sym} 2230 320 0 0 {name=p86 sig_type=std_logic lab=SLP}
