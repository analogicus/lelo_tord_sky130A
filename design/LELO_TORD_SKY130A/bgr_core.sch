v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 1150 210 1370 210 {}
L 4 1370 210 1370 370 {}
L 4 1150 370 1370 370 {}
L 4 1150 210 1150 370 {}
T {DUMMY resistors} 1170 340 0 0 0.4 0.4 {}
N 950 270 990 270 {lab=VCTRL}
N 1070 220 1070 270 {lab=VDD}
N 1030 220 1070 220 {lab=VDD}
N 1030 180 1030 240 {lab=VDD}
N 1030 270 1070 270 {lab=VDD}
N 1030 300 1030 440 {lab=VSRC}
N 810 440 810 600 {lab=VSRC}
N 1250 1080 1250 1140 {lab=V2C}
N 1210 1040 1230 1040 {lab=VSS}
N 1210 1040 1210 1240 {lab=VSS}
N 470 1240 1630 1240 {lab=VSS}
N 810 1200 810 1240 {lab=VSS}
N 750 1170 770 1170 {lab=VSS}
N 750 1170 750 1240 {lab=VSS}
N 1250 1200 1250 1240 {lab=VSS}
N 1290 1170 1310 1170 {lab=VSS}
N 1310 1170 1310 1240 {lab=VSS}
N 1250 700 1250 850 {lab=V2A}
N 950 860 990 860 {lab=V1B}
N 730 680 770 680 {lab=VDD}
N 730 650 770 650 {lab=SWBRANCH1}
N 1300 680 1340 680 {lab=VSS}
N 1170 680 1210 680 {lab=VDD}
N 1170 650 1210 650 {lab=SWBRANCH2}
N 1430 1070 1430 1240 {lab=VSS}
N 1430 860 1430 1000 {lab=V2}
N 1250 440 1250 600 {lab=VSRC}
N 810 700 810 850 {lab=V1A}
N 630 1070 630 1240 {lab=VSS}
N 810 870 810 1140 {lab=V1A}
N 990 860 990 1000 {lab=V1B}
N 990 1080 990 1120 {lab=MIDLERES1}
N 990 1200 990 1240 {lab=VSS}
N 950 1040 970 1040 {lab=VSS}
N 950 1040 950 1240 {lab=VSS}
N 950 1160 970 1160 {lab=VSS}
N 1070 1080 1070 1120 {lab=MIDLERES2}
N 1090 1040 1110 1040 {lab=VSS}
N 1110 1040 1110 1240 {lab=VSS}
N 1090 1160 1110 1160 {lab=VSS}
N 1070 1200 1070 1240 {lab=VSS}
N 1370 910 1370 950 {lab=VSS}
N 1370 780 1370 820 {lab=VDD}
N 1340 780 1340 820 {lab=SWCAP2}
N 1390 860 1590 860 {lab=V2}
N 630 860 630 1000 {lab=V1}
N 690 910 690 950 {lab=VSS}
N 690 780 690 820 {lab=VDD}
N 720 780 720 820 {lab=SWCAP1}
N 1250 870 1250 1000 {lab=V2A}
N 800 850 800 870 {lab=V1A}
N 800 870 820 870 {lab=V1A}
N 820 850 820 870 {lab=V1A}
N 800 850 820 850 {lab=V1A}
N 1240 850 1240 870 {lab=V2A}
N 1240 870 1260 870 {lab=V2A}
N 1260 850 1260 870 {lab=V2A}
N 1240 850 1260 850 {lab=V2A}
N 930 910 930 950 {lab=VSS}
N 930 780 930 820 {lab=VDD}
N 900 780 900 820 {lab=SWBGR1}
N 1130 910 1130 950 {lab=VSS}
N 1130 780 1130 820 {lab=VDD}
N 1160 780 1160 820 {lab=SWBGR2}
N 1070 860 1110 860 {lab=V2B}
N 1070 860 1070 1000 {lab=V2B}
N 860 680 900 680 {lab=VSS}
N 1550 860 1550 1000 {lab=V2}
N 1550 1060 1550 1240 {lab=VSS}
N 470 860 670 860 {lab=V1}
N 510 860 510 1000 {lab=V1}
N 510 1060 510 1240 {lab=VSS}
N 430 1030 470 1030 {lab=SWDRAIN1}
N 510 1030 550 1030 {lab=VSS}
N 550 1030 550 1080 {lab=VSS}
N 510 1080 550 1080 {lab=VSS}
N 1510 1030 1550 1030 {lab=VSS}
N 1510 1030 1510 1080 {lab=VSS}
N 1510 1080 1550 1080 {lab=VSS}
N 1590 1030 1630 1030 {lab=SWDRAIN2}
N 510 440 550 440 {lab=IPTAT}
N 570 490 570 530 {lab=VSS}
N 570 360 570 400 {lab=VDD}
N 600 360 600 400 {lab=SWPTAT}
N 650 440 810 440 {lab=VSRC}
N 1030 440 1250 440 {lab=VSRC}
N 1690 1040 1710 1040 {lab=VSS}
N 1690 1040 1690 1240 {lab=VSS}
N 1730 1080 1730 1240 {lab=VSS}
N 1730 440 1730 1000 {lab=VREF}
N 1830 1030 1870 1030 {lab=SWDRAIN3}
N 1730 1240 2350 1240 {lab=VSS}
N 2350 1060 2350 1240 {lab=VSS}
N 2210 1070 2210 1240 {lab=VSS}
N 2050 1070 2050 1240 {lab=VSS}
N 1910 1060 1910 1240 {lab=VSS}
N 1910 860 1910 1000 {lab=VCAPL}
N 2050 860 2050 1000 {lab=VCAPL}
N 2210 860 2210 1000 {lab=VCAPH}
N 2350 860 2350 1000 {lab=VCAPH}
N 1910 1030 1950 1030 {lab=VSS}
N 1950 1030 1950 1080 {lab=VSS}
N 1910 1080 1950 1080 {lab=VSS}
N 2310 1030 2350 1030 {lab=VSS}
N 2310 1030 2310 1080 {lab=VSS}
N 2310 1080 2350 1080 {lab=VSS}
N 1910 860 2050 860 {lab=VCAPL}
N 2210 860 2350 860 {lab=VCAPH}
N 2050 700 2050 860 {lab=VCAPL}
N 2210 700 2210 860 {lab=VCAPH}
N 2100 680 2160 680 {lab=VSS}
N 1990 680 2030 680 {lab=VDD}
N 1990 650 2030 650 {lab=SWCAPL}
N 2050 440 2050 600 {lab=#net1}
N 2250 680 2290 680 {lab=VDD}
N 2250 650 2290 650 {lab=SWCAPH}
N 2210 440 2210 600 {lab=#net1}
N 2050 440 2210 440 {lab=#net1}
N 2390 1030 2430 1030 {lab=SWDRAIN4}
N 1250 280 1250 320 {lab=VSS}
N 1250 320 1270 320 {lab=VSS}
N 1250 240 1250 280 {lab=VSS}
N 1250 240 1270 240 {lab=VSS}
N 1610 490 1610 530 {lab=VSS}
N 1610 360 1610 400 {lab=VDD}
N 1630 440 1830 440 {lab=VREF}
N 2510 440 2510 1000 {lab=VOUT}
N 2510 1070 2510 1240 {lab=VSS}
N 2350 1240 2510 1240 {lab=VSS}
N 1910 490 1910 530 {lab=VSS}
N 1910 360 1910 400 {lab=VDD}
N 1880 320 1880 400 {lab=SWREF}
N 2510 440 2590 440 {lab=VOUT}
N 1580 320 1880 320 {lab=SWREF}
N 1730 280 1730 320 {lab=SWREF}
N 1580 320 1580 400 {lab=SWREF}
N 1930 440 2050 440 {lab=#net1}
N 770 860 800 860 {lab=V1A}
N 820 860 850 860 {lab=V1A}
N 1210 860 1240 860 {lab=V2A}
N 1260 860 1290 860 {lab=V2A}
N 810 440 1030 440 {lab=VSRC}
N 1630 1240 1950 1240 {lab=VSS}
N 1250 440 1530 440 {lab=VSRC}
N 2390 490 2390 530 {lab=VSS}
N 2390 360 2390 400 {lab=VDD}
N 2210 440 2310 440 {lab=#net1}
N 2410 440 2510 440 {lab=VOUT}
N 2360 360 2360 400 {lab=SWAVG}
N 2650 1060 2650 1240 {lab=VSS}
N 2650 860 2650 1000 {lab=VOUT}
N 2610 1030 2650 1030 {lab=VSS}
N 2610 1030 2610 1080 {lab=VSS}
N 2610 1080 2650 1080 {lab=VSS}
N 2510 860 2650 860 {lab=VOUT}
N 2510 1240 2650 1240 {lab=VSS}
N 2690 1030 2730 1030 {lab=SWDRAIN5}
N 2550 410 2590 410 {lab=V2}
N 2550 380 2590 380 {lab=IPTAT}
N 2550 470 2590 470 {lab=V1}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 990 270 0 0 {name=x1 }
C {sky130_fd_pr/pnp_05v5.sym} 790 1170 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 1270 1170 0 1 {name=Q2[7:0]
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 810 590 3 1 {name=x2 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1250 590 3 1 {name=x3 }
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 1430 1060 0 1 {name=x11[9:0]
}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 630 1060 0 0 {name=x10[9:0]
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1280 860 0 0 {name=x4 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 780 860 0 1 {name=x5 }
C {devices/opin.sym} 2590 410 0 0 {name=p6 lab=V2}
C {devices/ipin.sym} 350 1230 0 0 {name=p4 lab=VSS}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 840 860 0 0 {name=x6 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1220 860 0 1 {name=x7 }
C {devices/ipin.sym} 350 190 0 0 {name=p3 lab=VDD}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 470 1030 0 0 {name=x8 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1590 1030 0 1 {name=x9 }
C {devices/ipin.sym} 350 1030 0 0 {name=p7 lab=SWDRAIN1}
C {devices/lab_wire.sym} 690 940 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 690 810 0 0 {name=p10 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 760 650 0 0 {name=p11 sig_type=std_logic lab=SWBRANCH1}
C {devices/lab_wire.sym} 760 680 0 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 870 680 0 1 {name=p13 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 930 810 0 1 {name=p14 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 930 940 0 1 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 720 810 0 1 {name=p16 sig_type=std_logic lab=SWCAP1}
C {devices/lab_wire.sym} 900 810 0 0 {name=p17 sig_type=std_logic lab=SWBGR1}
C {devices/lab_wire.sym} 1160 810 0 1 {name=p18 sig_type=std_logic lab=SWBGR2}
C {devices/lab_wire.sym} 1340 810 0 0 {name=p19 sig_type=std_logic lab=SWCAP2}
C {devices/lab_wire.sym} 1130 810 0 0 {name=p20 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1370 810 0 1 {name=p21 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1130 940 0 0 {name=p22 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1370 940 0 1 {name=p23 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1310 680 0 1 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1200 650 0 0 {name=p24 sig_type=std_logic lab=SWBRANCH2}
C {devices/lab_wire.sym} 1200 680 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {devices/opin.sym} 2590 470 2 1 {name=p26 lab=V1}
C {devices/opin.sym} 2590 380 0 0 {name=p5 lab=IPTAT}
C {devices/ipin.sym} 350 650 0 0 {name=p27 lab=SWBRANCH1}
C {devices/ipin.sym} 350 680 0 0 {name=p28 lab=SWBRANCH2}
C {devices/ipin.sym} 350 830 0 0 {name=p30 lab=SWCAP1}
C {devices/ipin.sym} 350 860 0 0 {name=p31 lab=SWCAP2}
C {devices/ipin.sym} 350 890 0 0 {name=p32 lab=SWBGR1}
C {devices/ipin.sym} 350 920 0 0 {name=p33 lab=SWBGR2}
C {devices/ipin.sym} 350 270 0 0 {name=p34 lab=VCTRL}
C {devices/lab_wire.sym} 500 1240 0 0 {name=p35 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1030 210 0 0 {name=p38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 980 270 0 0 {name=p37 sig_type=std_logic lab=VCTRL}
C {devices/lab_wire.sym} 460 1030 0 0 {name=p1 sig_type=std_logic lab=SWDRAIN1}
C {devices/lab_wire.sym} 1600 1030 0 1 {name=p39 sig_type=std_logic lab=SWDRAIN2}
C {devices/lab_wire.sym} 820 870 2 0 {name=p8 sig_type=std_logic lab=V1A}
C {devices/lab_wire.sym} 990 860 0 1 {name=p29 sig_type=std_logic lab=V1B}
C {devices/lab_wire.sym} 1070 860 0 0 {name=p40 sig_type=std_logic lab=V2B}
C {devices/lab_wire.sym} 1260 850 0 1 {name=p41 sig_type=std_logic lab=V2A}
C {devices/lab_wire.sym} 1250 1120 0 0 {name=p42 sig_type=std_logic lab=V2C}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 1070 1120 3 1 {name=x14[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 990 1120 1 0 {name=x15[1:0]}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 660 440 0 1 {name=x10 }
C {devices/lab_wire.sym} 600 390 0 1 {name=p43 sig_type=std_logic lab=SWPTAT}
C {devices/lab_wire.sym} 570 390 0 0 {name=p44 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 570 520 0 0 {name=p45 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 350 440 0 0 {name=p46 lab=SWPTAT}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 1730 1000 1 0 {name=x1[1:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2050 1060 0 0 {name=x3[5:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2210 1060 0 0 {name=x4[5:0]}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1870 1030 0 0 {name=x13 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 2390 1030 0 1 {name=x14 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2050 590 3 1 {name=x15 }
C {devices/lab_wire.sym} 2120 680 0 1 {name=p36 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2000 650 0 0 {name=p47 sig_type=std_logic lab=SWCAPL}
C {devices/lab_wire.sym} 2000 680 0 0 {name=p48 sig_type=std_logic lab=VDD}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2210 590 1 0 {name=x16 }
C {devices/lab_wire.sym} 2260 650 0 1 {name=p50 sig_type=std_logic lab=SWCAPH}
C {devices/lab_wire.sym} 2260 680 0 1 {name=p51 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1860 1030 0 0 {name=p49 sig_type=std_logic lab=SWDRAIN3}
C {devices/lab_wire.sym} 2400 1030 0 1 {name=p52 sig_type=std_logic lab=SWDRAIN4}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 1270 240 1 0 {name=x17 }
C {devices/lab_wire.sym} 1250 300 2 1 {name=p53 sig_type=std_logic lab=VSS}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1520 440 0 0 {name=x18 }
C {devices/lab_wire.sym} 1730 310 0 1 {name=p54 sig_type=std_logic lab=SWREF}
C {devices/lab_wire.sym} 1610 390 0 1 {name=p55 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1610 520 0 1 {name=p56 sig_type=std_logic lab=VSS}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 2510 1060 0 0 {name=x19[11:0]}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1820 440 0 0 {name=x20 }
C {devices/lab_wire.sym} 1910 390 0 1 {name=p58 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1910 520 0 1 {name=p59 sig_type=std_logic lab=VSS}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2300 440 0 0 {name=x21}
C {devices/lab_wire.sym} 2390 390 0 1 {name=p57 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2390 520 0 1 {name=p60 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 2590 440 0 0 {name=p61 lab=VOUT}
C {devices/ipin.sym} 350 1060 0 0 {name=p62 lab=SWDRAIN2}
C {devices/ipin.sym} 350 1090 0 0 {name=p63 lab=SWDRAIN3}
C {devices/ipin.sym} 350 1120 0 0 {name=p64 lab=SWDRAIN4}
C {devices/ipin.sym} 350 1150 0 0 {name=p65 lab=SWDRAIN5}
C {devices/lab_wire.sym} 2360 380 0 0 {name=p66 sig_type=std_logic lab=SWAVG}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 2690 1030 0 1 {name=x22 }
C {devices/lab_wire.sym} 2700 1030 0 1 {name=p67 sig_type=std_logic lab=SWDRAIN5}
C {devices/ipin.sym} 350 470 0 0 {name=p68 lab=SWREF}
C {devices/ipin.sym} 350 500 0 0 {name=p69 lab=SWCAPL}
C {devices/ipin.sym} 350 530 0 0 {name=p70 lab=SWCAPH}
C {devices/ipin.sym} 350 560 0 0 {name=p71 lab=SWAVG}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 1250 1080 1 1 {name=x2[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 990 1000 1 0 {name=x13[1:0] }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 1070 1000 3 1 {name=x12[1:0]}
C {devices/lab_wire.sym} 2050 850 0 0 {name=p72 sig_type=std_logic lab=VCAPL}
C {devices/lab_wire.sym} 2210 850 0 1 {name=p73 sig_type=std_logic lab=VCAPH}
C {devices/lab_wire.sym} 1720 440 0 1 {name=p74 sig_type=std_logic lab=VREF}
C {devices/lab_pin.sym} 470 860 0 0 {name=p75 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 510 440 0 0 {name=p76 sig_type=std_logic lab=IPTAT}
C {devices/lab_pin.sym} 1590 860 0 1 {name=p77 sig_type=std_logic lab=V2}
C {devices/lab_wire.sym} 1040 440 0 1 {name=p78 sig_type=std_logic lab=VSRC}
C {devices/lab_wire.sym} 990 1110 0 0 {name=p79 sig_type=std_logic lab=MIDLERES1}
C {devices/lab_wire.sym} 1070 1110 0 1 {name=p80 sig_type=std_logic lab=MIDLERES2}
