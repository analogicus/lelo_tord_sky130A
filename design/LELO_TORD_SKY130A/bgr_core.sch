v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 120 10 340 10 {}
L 4 340 10 340 170 {}
L 4 120 170 340 170 {}
L 4 120 10 120 170 {}
T {DUMMY resistors} 140 140 0 0 0.4 0.4 {}
N -80 70 -40 70 {lab=VCTRL}
N 40 20 40 70 {lab=VDD}
N 0 20 40 20 {lab=VDD}
N 0 -20 0 40 {lab=VDD}
N 0 70 40 70 {lab=VDD}
N 0 100 0 240 {lab=PMOS_DRAIN}
N -220 240 -220 400 {lab=PMOS_DRAIN}
N 220 880 220 940 {lab=V2C}
N 180 840 200 840 {lab=VSS}
N 180 840 180 1040 {lab=VSS}
N -560 1040 600 1040 {lab=VSS}
N -220 1000 -220 1040 {lab=VSS}
N -280 970 -260 970 {lab=VSS}
N -280 970 -280 1040 {lab=VSS}
N 220 1000 220 1040 {lab=VSS}
N 260 970 280 970 {lab=VSS}
N 280 970 280 1040 {lab=VSS}
N 220 500 220 650 {lab=V2A}
N -80 660 -40 660 {lab=V1B}
N -300 480 -260 480 {lab=VDD}
N -300 450 -260 450 {lab=SWBRANCH1}
N 270 480 310 480 {lab=VSS}
N 140 480 180 480 {lab=VDD}
N 140 450 180 450 {lab=SWBRANCH2}
N 400 870 400 1040 {lab=VSS}
N 400 660 400 800 {lab=V2}
N 220 240 220 400 {lab=PMOS_DRAIN}
N -220 500 -220 650 {lab=V1A}
N -400 870 -400 1040 {lab=VSS}
N -220 670 -220 940 {lab=V1A}
N -40 660 -40 800 {lab=V1B}
N -40 880 -40 920 {lab=MIDLERES1}
N -40 1000 -40 1040 {lab=VSS}
N -80 840 -60 840 {lab=VSS}
N -80 840 -80 1040 {lab=VSS}
N -80 960 -60 960 {lab=VSS}
N 40 880 40 920 {lab=MIDLERES2}
N 60 840 80 840 {lab=VSS}
N 80 840 80 1040 {lab=VSS}
N 60 960 80 960 {lab=VSS}
N 40 1000 40 1040 {lab=VSS}
N 340 710 340 750 {lab=VSS}
N 340 580 340 620 {lab=VDD}
N 310 580 310 620 {lab=SWCAP2}
N 360 660 560 660 {lab=V2}
N -400 660 -400 800 {lab=V1}
N -340 710 -340 750 {lab=VSS}
N -340 580 -340 620 {lab=VDD}
N -310 580 -310 620 {lab=SWCAP1}
N 220 670 220 800 {lab=V2A}
N -230 650 -230 670 {lab=V1A}
N -230 670 -210 670 {lab=V1A}
N -210 650 -210 670 {lab=V1A}
N -230 650 -210 650 {lab=V1A}
N 210 650 210 670 {lab=V2A}
N 210 670 230 670 {lab=V2A}
N 230 650 230 670 {lab=V2A}
N 210 650 230 650 {lab=V2A}
N -100 710 -100 750 {lab=VSS}
N -100 580 -100 620 {lab=VDD}
N -130 580 -130 620 {lab=SWBGR1}
N 100 710 100 750 {lab=VSS}
N 100 580 100 620 {lab=VDD}
N 130 580 130 620 {lab=SWBGR2}
N 40 660 80 660 {lab=V2B}
N 40 660 40 800 {lab=V2B}
N -170 480 -130 480 {lab=VSS}
N 520 660 520 800 {lab=V2}
N 520 860 520 1040 {lab=VSS}
N -560 660 -360 660 {lab=V1}
N -520 660 -520 800 {lab=V1}
N -520 860 -520 1040 {lab=VSS}
N -600 830 -560 830 {lab=SWDRAIN1}
N -520 830 -480 830 {lab=VSS}
N -480 830 -480 880 {lab=VSS}
N -520 880 -480 880 {lab=VSS}
N 480 830 520 830 {lab=VSS}
N 480 830 480 880 {lab=VSS}
N 480 880 520 880 {lab=VSS}
N 560 830 600 830 {lab=SWDRAIN2}
N -520 240 -480 240 {lab=IPTAT}
N -460 290 -460 330 {lab=VSS}
N -460 160 -460 200 {lab=VDD}
N -430 160 -430 200 {lab=SWPTAT}
N -380 240 -220 240 {lab=PMOS_DRAIN}
N -0 240 220 240 {lab=PMOS_DRAIN}
N 660 840 680 840 {lab=VSS}
N 660 840 660 1040 {lab=VSS}
N 700 880 700 1040 {lab=VSS}
N 700 240 700 800 {lab=VREF}
N 800 830 840 830 {lab=SWDRAIN3}
N 700 1040 1320 1040 {lab=VSS}
N 1320 860 1320 1040 {lab=VSS}
N 1180 870 1180 1040 {lab=VSS}
N 1020 870 1020 1040 {lab=VSS}
N 880 860 880 1040 {lab=VSS}
N 880 660 880 800 {lab=VCAPL}
N 1020 660 1020 800 {lab=VCAPL}
N 1180 660 1180 800 {lab=VCAPH}
N 1320 660 1320 800 {lab=VCAPH}
N 880 830 920 830 {lab=VSS}
N 920 830 920 880 {lab=VSS}
N 880 880 920 880 {lab=VSS}
N 1280 830 1320 830 {lab=VSS}
N 1280 830 1280 880 {lab=VSS}
N 1280 880 1320 880 {lab=VSS}
N 880 660 1020 660 {lab=VCAPL}
N 1180 660 1320 660 {lab=VCAPH}
N 1020 500 1020 660 {lab=VCAPL}
N 1180 500 1180 660 {lab=VCAPH}
N 1070 480 1130 480 {lab=VSS}
N 960 480 1000 480 {lab=VDD}
N 960 450 1000 450 {lab=SWCAPL}
N 1020 240 1020 400 {lab=#net1}
N 1220 480 1260 480 {lab=VDD}
N 1220 450 1260 450 {lab=SWCAPH}
N 1180 240 1180 400 {lab=#net1}
N 1020 240 1180 240 {lab=#net1}
N 1360 830 1400 830 {lab=SWDRAIN4}
N 220 80 220 120 {lab=VSS}
N 220 120 240 120 {lab=VSS}
N 220 40 220 80 {lab=VSS}
N 220 40 240 40 {lab=VSS}
N 580 290 580 330 {lab=VSS}
N 580 160 580 200 {lab=VDD}
N 600 240 800 240 {lab=VREF}
N 1480 240 1480 800 {lab=VAVG}
N 1480 870 1480 1040 {lab=VSS}
N 1320 1040 1480 1040 {lab=VSS}
N 880 290 880 330 {lab=VSS}
N 880 160 880 200 {lab=VDD}
N 850 120 850 200 {lab=SWREF}
N 1480 240 1540 240 {lab=VAVG}
N 550 120 850 120 {lab=SWREF}
N 700 80 700 120 {lab=SWREF}
N 550 120 550 200 {lab=SWREF}
N 900 240 1020 240 {lab=#net1}
N -260 660 -230 660 {lab=V1A}
N -210 660 -180 660 {lab=V1A}
N 180 660 210 660 {lab=V2A}
N 230 660 260 660 {lab=V2A}
N -220 240 -0 240 {lab=PMOS_DRAIN}
N 600 1040 920 1040 {lab=VSS}
N 220 240 500 240 {lab=PMOS_DRAIN}
N 1360 290 1360 330 {lab=VSS}
N 1360 160 1360 200 {lab=VDD}
N 1180 240 1280 240 {lab=#net1}
N 1380 240 1480 240 {lab=VAVG}
N 1330 160 1330 200 {lab=SWAVG}
N 1620 860 1620 1040 {lab=VSS}
N 1620 660 1620 800 {lab=VAVG}
N 1580 830 1620 830 {lab=VSS}
N 1580 830 1580 880 {lab=VSS}
N 1580 880 1620 880 {lab=VSS}
N 1480 660 1620 660 {lab=VAVG}
N 1480 1040 1620 1040 {lab=VSS}
N 1660 830 1700 830 {lab=SWDRAIN5}
N 1500 210 1540 210 {lab=V2}
N 1500 180 1540 180 {lab=IPTAT}
N 1500 270 1540 270 {lab=V1}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} -40 70 0 0 {name=x1 }
C {sky130_fd_pr/pnp_05v5.sym} -240 970 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 240 970 0 1 {name=Q2[7:0]
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} -220 390 3 1 {name=x2 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 220 390 3 1 {name=x3 }
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 400 860 0 1 {name=x11[9:0]
}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} -400 860 0 0 {name=x10[9:0]
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 250 660 0 0 {name=x4 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} -250 660 0 1 {name=x5 }
C {devices/opin.sym} 1540 210 0 0 {name=p6 lab=V2}
C {devices/ipin.sym} -680 1030 0 0 {name=p4 lab=VSS}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} -190 660 0 0 {name=x6 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 190 660 0 1 {name=x7 }
C {devices/ipin.sym} -680 -10 0 0 {name=p3 lab=VDD}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} -560 830 0 0 {name=x8 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 560 830 0 1 {name=x9 }
C {devices/ipin.sym} -680 830 0 0 {name=p7 lab=SWDRAIN1}
C {devices/lab_wire.sym} -340 740 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -340 610 0 0 {name=p10 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -270 450 0 0 {name=p11 sig_type=std_logic lab=SWBRANCH1}
C {devices/lab_wire.sym} -270 480 0 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -160 480 0 1 {name=p13 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -100 610 0 1 {name=p14 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -100 740 0 1 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -310 610 0 1 {name=p16 sig_type=std_logic lab=SWCAP1}
C {devices/lab_wire.sym} -130 610 0 0 {name=p17 sig_type=std_logic lab=SWBGR1}
C {devices/lab_wire.sym} 130 610 0 1 {name=p18 sig_type=std_logic lab=SWBGR2}
C {devices/lab_wire.sym} 310 610 0 0 {name=p19 sig_type=std_logic lab=SWCAP2}
C {devices/lab_wire.sym} 100 610 0 0 {name=p20 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 340 610 0 1 {name=p21 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 100 740 0 0 {name=p22 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 340 740 0 1 {name=p23 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 280 480 0 1 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 170 450 0 0 {name=p24 sig_type=std_logic lab=SWBRANCH2}
C {devices/lab_wire.sym} 170 480 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {devices/opin.sym} 1540 270 2 1 {name=p26 lab=V1}
C {devices/opin.sym} 1540 180 0 0 {name=p5 lab=IPTAT}
C {devices/ipin.sym} -680 450 0 0 {name=p27 lab=SWBRANCH1}
C {devices/ipin.sym} -680 480 0 0 {name=p28 lab=SWBRANCH2}
C {devices/ipin.sym} -680 630 0 0 {name=p30 lab=SWCAP1}
C {devices/ipin.sym} -680 660 0 0 {name=p31 lab=SWCAP2}
C {devices/ipin.sym} -680 690 0 0 {name=p32 lab=SWBGR1}
C {devices/ipin.sym} -680 720 0 0 {name=p33 lab=SWBGR2}
C {devices/ipin.sym} -680 70 0 0 {name=p34 lab=VCTRL}
C {devices/lab_wire.sym} -530 1040 0 0 {name=p35 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 0 10 0 0 {name=p38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -50 70 0 0 {name=p37 sig_type=std_logic lab=VCTRL}
C {devices/lab_wire.sym} -570 830 0 0 {name=p1 sig_type=std_logic lab=SWDRAIN1}
C {devices/lab_wire.sym} 570 830 0 1 {name=p39 sig_type=std_logic lab=SWDRAIN2}
C {devices/lab_wire.sym} -210 670 2 0 {name=p8 sig_type=std_logic lab=V1A}
C {devices/lab_wire.sym} -40 660 0 1 {name=p29 sig_type=std_logic lab=V1B}
C {devices/lab_wire.sym} 40 660 0 0 {name=p40 sig_type=std_logic lab=V2B}
C {devices/lab_wire.sym} 230 650 0 1 {name=p41 sig_type=std_logic lab=V2A}
C {devices/lab_wire.sym} 220 920 0 0 {name=p42 sig_type=std_logic lab=V2C}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 40 920 3 1 {name=x14[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} -40 920 1 0 {name=x15[1:0]}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} -370 240 0 1 {name=x10 }
C {devices/lab_wire.sym} -430 190 0 1 {name=p43 sig_type=std_logic lab=SWPTAT}
C {devices/lab_wire.sym} -460 190 0 0 {name=p44 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} -460 320 0 0 {name=p45 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} -680 240 0 0 {name=p46 lab=SWPTAT}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 700 800 1 0 {name=x1[1:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 1020 860 0 0 {name=x3[5:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 1180 860 0 0 {name=x4[5:0]}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 840 830 0 0 {name=x13 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1360 830 0 1 {name=x14 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1020 390 3 1 {name=x15 }
C {devices/lab_wire.sym} 1090 480 0 1 {name=p36 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 970 450 0 0 {name=p47 sig_type=std_logic lab=SWCAPL}
C {devices/lab_wire.sym} 970 480 0 0 {name=p48 sig_type=std_logic lab=VDD}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1180 390 1 0 {name=x16 }
C {devices/lab_wire.sym} 1230 450 0 1 {name=p50 sig_type=std_logic lab=SWCAPH}
C {devices/lab_wire.sym} 1230 480 0 1 {name=p51 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 830 830 0 0 {name=p49 sig_type=std_logic lab=SWDRAIN3}
C {devices/lab_wire.sym} 1370 830 0 1 {name=p52 sig_type=std_logic lab=SWDRAIN4}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 240 40 1 0 {name=x17 }
C {devices/lab_wire.sym} 220 100 2 1 {name=p53 sig_type=std_logic lab=VSS}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 490 240 0 0 {name=x18 }
C {devices/lab_wire.sym} 700 110 0 1 {name=p54 sig_type=std_logic lab=SWREF}
C {devices/lab_wire.sym} 580 190 0 1 {name=p55 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 580 320 0 1 {name=p56 sig_type=std_logic lab=VSS}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 1480 860 0 0 {name=x19[11:0]}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 790 240 0 0 {name=x20 }
C {devices/lab_wire.sym} 880 190 0 1 {name=p58 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 320 0 1 {name=p59 sig_type=std_logic lab=VSS}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1270 240 0 0 {name=x21}
C {devices/lab_wire.sym} 1360 190 0 1 {name=p57 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1360 320 0 1 {name=p60 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 1540 240 0 0 {name=p61 lab=VAVG}
C {devices/ipin.sym} -680 860 0 0 {name=p62 lab=SWDRAIN2}
C {devices/ipin.sym} -680 890 0 0 {name=p63 lab=SWDRAIN3}
C {devices/ipin.sym} -680 920 0 0 {name=p64 lab=SWDRAIN4}
C {devices/ipin.sym} -680 950 0 0 {name=p65 lab=SWDRAIN5}
C {devices/lab_wire.sym} 1330 180 0 0 {name=p66 sig_type=std_logic lab=SWAVG}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1660 830 0 1 {name=x22 }
C {devices/lab_wire.sym} 1670 830 0 1 {name=p67 sig_type=std_logic lab=SWDRAIN5}
C {devices/ipin.sym} -680 270 0 0 {name=p68 lab=SWREF}
C {devices/ipin.sym} -680 300 0 0 {name=p69 lab=SWCAPL}
C {devices/ipin.sym} -680 330 0 0 {name=p70 lab=SWCAPH}
C {devices/ipin.sym} -680 360 0 0 {name=p71 lab=SWAVG}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 220 880 1 1 {name=x2[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} -40 800 1 0 {name=x13[1:0] }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 40 800 3 1 {name=x12[1:0]}
C {devices/lab_wire.sym} 1020 650 0 0 {name=p72 sig_type=std_logic lab=VCAPL}
C {devices/lab_wire.sym} 1180 650 0 1 {name=p73 sig_type=std_logic lab=VCAPH}
C {devices/lab_wire.sym} 690 240 0 1 {name=p74 sig_type=std_logic lab=VREF}
C {devices/lab_pin.sym} -560 660 0 0 {name=p75 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} -520 240 0 0 {name=p76 sig_type=std_logic lab=IPTAT}
C {devices/lab_pin.sym} 560 660 0 1 {name=p77 sig_type=std_logic lab=V2}
C {devices/lab_wire.sym} 10 240 0 1 {name=p78 sig_type=std_logic lab=PMOS_DRAIN}
C {devices/lab_wire.sym} -40 910 0 0 {name=p79 sig_type=std_logic lab=MIDLERES1}
C {devices/lab_wire.sym} 40 910 0 1 {name=p80 sig_type=std_logic lab=MIDLERES2}
