v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 1220 600 1260 600 {lab=VSS}
N 1220 720 1260 720 {lab=B4}
N 1220 700 1260 700 {lab=B3}
N 1220 680 1260 680 {lab=B2}
N 1220 660 1260 660 {lab=B1}
N 1220 640 1260 640 {lab=B0}
N 1220 560 1260 560 {lab=VDD}
N 1220 580 1260 580 {lab=SLP}
N 1220 620 1260 620 {lab=BT}
N 1220 780 1260 780 {lab=B7}
N 1220 760 1260 760 {lab=B6}
N 1220 740 1260 740 {lab=B5}
N 2620 600 2660 600 {lab=VSS}
N 2620 720 2660 720 {lab=B4}
N 2620 700 2660 700 {lab=B3}
N 2620 680 2660 680 {lab=B2}
N 2620 660 2660 660 {lab=B1}
N 2620 640 2660 640 {lab=B0}
N 2620 560 2660 560 {lab=VDD}
N 2620 580 2660 580 {lab=SLP}
N 2620 620 2660 620 {lab=BT}
N 2620 780 2660 780 {lab=B7}
N 2620 760 2660 760 {lab=B6}
N 2620 740 2660 740 {lab=B5}
N 1720 560 1720 640 {lab=SRC1}
N 2160 1120 2160 1180 {lab=V2C}
N 2120 1080 2140 1080 {lab=VSS}
N 2120 1080 2120 1280 {lab=VSS}
N 1380 1280 2500 1280 {lab=VSS}
N 1720 1240 1720 1280 {lab=VSS}
N 1660 1210 1680 1210 {lab=VSS}
N 1660 1210 1660 1280 {lab=VSS}
N 2160 1240 2160 1280 {lab=VSS}
N 2200 1210 2220 1210 {lab=VSS}
N 2220 1210 2220 1280 {lab=VSS}
N 2160 740 2160 890 {lab=V2A}
N 1860 900 1900 900 {lab=V1B}
N 1760 720 1800 720 {lab=VDD}
N 1760 690 1800 690 {lab=SWBRN1}
N 2210 720 2250 720 {lab=VSS}
N 2080 720 2120 720 {lab=VDD}
N 2080 690 2120 690 {lab=SWBRN2}
N 2340 1110 2340 1280 {lab=VSS}
N 2340 900 2340 1040 {lab=V2}
N 2160 560 2160 640 {lab=SRC2}
N 1720 740 1720 890 {lab=V1A}
N 1540 1110 1540 1280 {lab=VSS}
N 1720 910 1720 1180 {lab=V1A}
N 1900 900 1900 1040 {lab=V1B}
N 1900 1120 1900 1160 {lab=R1}
N 1900 1240 1900 1280 {lab=VSS}
N 1860 1080 1880 1080 {lab=VSS}
N 1860 1080 1860 1280 {lab=VSS}
N 1860 1200 1880 1200 {lab=VSS}
N 1980 1120 1980 1160 {lab=R2}
N 2000 1080 2020 1080 {lab=VSS}
N 2020 1080 2020 1280 {lab=VSS}
N 2000 1200 2020 1200 {lab=VSS}
N 1980 1240 1980 1280 {lab=VSS}
N 2280 950 2280 990 {lab=VSS}
N 2280 820 2280 860 {lab=VDD}
N 2250 820 2250 860 {lab=SWCAP2}
N 2300 900 2340 900 {lab=V2}
N 1540 900 1540 1040 {lab=V1}
N 1600 950 1600 990 {lab=VSS}
N 1600 820 1600 860 {lab=VDD}
N 1630 820 1630 860 {lab=SWCAP1}
N 2160 910 2160 1040 {lab=V2A}
N 1710 890 1710 910 {lab=V1A}
N 1710 910 1730 910 {lab=V1A}
N 1730 890 1730 910 {lab=V1A}
N 1710 890 1730 890 {lab=V1A}
N 2150 890 2150 910 {lab=V2A}
N 2150 910 2170 910 {lab=V2A}
N 2170 890 2170 910 {lab=V2A}
N 2150 890 2170 890 {lab=V2A}
N 1840 950 1840 990 {lab=VSS}
N 1840 820 1840 860 {lab=VDD}
N 1810 820 1810 860 {lab=SWBGR1}
N 2040 950 2040 990 {lab=VSS}
N 2040 820 2040 860 {lab=VDD}
N 2070 820 2070 860 {lab=SWBGR2}
N 1980 900 2020 900 {lab=V2B}
N 1980 900 1980 1040 {lab=V2B}
N 1630 720 1670 720 {lab=VSS}
N 2460 900 2460 1040 {lab=V2}
N 2460 1100 2460 1280 {lab=VSS}
N 1380 900 1580 900 {lab=V1}
N 1420 900 1420 1040 {lab=V1}
N 1420 1100 1420 1280 {lab=VSS}
N 1340 1070 1380 1070 {lab=SWDRN1}
N 1420 1070 1460 1070 {lab=VSS}
N 1460 1070 1460 1120 {lab=VSS}
N 1420 1120 1460 1120 {lab=VSS}
N 2420 1070 2460 1070 {lab=VSS}
N 2420 1070 2420 1120 {lab=VSS}
N 2420 1120 2460 1120 {lab=VSS}
N 2500 1070 2540 1070 {lab=SWDRN2}
N 1680 900 1710 900 {lab=V1A}
N 1730 900 1760 900 {lab=V1A}
N 2120 900 2150 900 {lab=V2A}
N 2170 900 2200 900 {lab=V2A}
N 2160 560 2320 560 {lab=SRC2}
N 1560 560 1720 560 {lab=SRC1}
N 2460 900 2500 900 {lab=V2}
N 2460 880 2500 880 {lab=V1}
N 2340 900 2460 900 {lab=V2}
N 1220 820 1260 820 {lab=SWBRN1}
N 1220 840 1260 840 {lab=SWBRN2}
N 1220 870 1260 870 {lab=SWCAP1}
N 1220 890 1260 890 {lab=SWCAP2}
N 1220 920 1260 920 {lab=SWBGR1}
N 1220 940 1260 940 {lab=SWBGR2}
N 1220 970 1260 970 {lab=SWDRN1}
N 1220 990 1260 990 {lab=SWDRN2}
C {devices/ipin.sym} 1220 660 0 0 {name=p17 lab=B1}
C {devices/ipin.sym} 1220 680 0 0 {name=p18 lab=B2}
C {devices/ipin.sym} 1220 700 0 0 {name=p19 lab=B3}
C {devices/ipin.sym} 1220 720 0 0 {name=p20 lab=B4}
C {devices/ipin.sym} 1220 640 0 0 {name=p7 lab=B0}
C {devices/ipin.sym} 1220 600 0 0 {name=p1 lab=VSS}
C {devices/ipin.sym} 1220 560 0 0 {name=p2 lab=VDD}
C {devices/ipin.sym} 1220 580 0 0 {name=p3 lab=SLP}
C {devices/ipin.sym} 1220 620 0 0 {name=p4 lab=BT}
C {devices/ipin.sym} 1220 740 0 0 {name=p5 lab=B5}
C {devices/ipin.sym} 1220 760 0 0 {name=p6 lab=B6}
C {devices/ipin.sym} 1220 780 0 0 {name=p8 lab=B7}
C {devices/lab_wire.sym} 2160 560 0 1 {name=p41 sig_type=std_logic lab=SRC2}
C {devices/lab_wire.sym} 1720 560 0 0 {name=p43 sig_type=std_logic lab=SRC1}
C {sky130_fd_pr/pnp_05v5.sym} 1700 1210 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 2180 1210 0 1 {name=Q2[7:0]
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1720 630 1 0 {name=x3}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2160 630 3 1 {name=x4}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 2340 1100 0 1 {name=x16[9:0]
}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 1540 1100 0 0 {name=x10[9:0]
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2190 900 0 0 {name=x8}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1690 900 0 1 {name=x5}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1750 900 0 0 {name=x6}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2130 900 0 1 {name=x7}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1380 1070 0 0 {name=x9}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 2500 1070 0 1 {name=x17}
C {devices/lab_wire.sym} 1600 980 0 0 {name=p44 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1600 850 0 0 {name=p45 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 690 0 1 {name=p46 sig_type=std_logic lab=SWBRN1}
C {devices/lab_wire.sym} 1770 720 0 1 {name=p47 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1660 720 0 0 {name=p48 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1840 850 0 1 {name=p49 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1840 980 0 1 {name=p50 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1630 850 0 1 {name=p51 sig_type=std_logic lab=SWCAP1}
C {devices/lab_wire.sym} 1810 850 0 0 {name=p52 sig_type=std_logic lab=SWBGR1}
C {devices/lab_wire.sym} 2070 850 0 1 {name=p53 sig_type=std_logic lab=SWBGR2}
C {devices/lab_wire.sym} 2250 850 0 0 {name=p55 sig_type=std_logic lab=SWCAP2}
C {devices/lab_wire.sym} 2040 850 0 0 {name=p56 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2280 850 0 1 {name=p57 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2040 980 0 0 {name=p58 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2280 980 0 1 {name=p59 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2220 720 0 1 {name=p60 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2110 690 0 0 {name=p61 sig_type=std_logic lab=SWBRN2}
C {devices/lab_wire.sym} 2110 720 0 0 {name=p62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1370 1070 0 0 {name=p64 sig_type=std_logic lab=SWDRN1}
C {devices/lab_wire.sym} 2510 1070 0 1 {name=p65 sig_type=std_logic lab=SWDRN2}
C {devices/lab_wire.sym} 1730 910 2 0 {name=p66 sig_type=std_logic lab=V1A}
C {devices/lab_wire.sym} 1900 910 2 0 {name=p67 sig_type=std_logic lab=V1B}
C {devices/lab_wire.sym} 1980 910 2 1 {name=p68 sig_type=std_logic lab=V2B}
C {devices/lab_wire.sym} 2150 910 2 1 {name=p69 sig_type=std_logic lab=V2A}
C {devices/lab_wire.sym} 2160 1160 0 0 {name=p70 sig_type=std_logic lab=V2C}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 1980 1160 3 1 {name=x14[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 1900 1160 1 0 {name=x12[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 2160 1120 1 1 {name=x15[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 1900 1040 1 0 {name=x11[1:0] }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 1980 1040 3 1 {name=x13[1:0]}
C {devices/lab_pin.sym} 1380 900 0 0 {name=p75 sig_type=std_logic lab=V1}
C {devices/lab_wire.sym} 1900 1150 0 0 {name=p71 sig_type=std_logic lab=R1}
C {devices/lab_wire.sym} 1980 1150 0 1 {name=p80 sig_type=std_logic lab=R2}
C {devices/opin.sym} 2500 900 0 0 {name=p21 lab=V2}
C {devices/opin.sym} 2500 880 2 1 {name=p26 lab=V1}
C {devices/lab_wire.sym} 2630 600 0 1 {name=p9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2630 560 0 1 {name=p10 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2630 580 0 1 {name=p11 sig_type=std_logic lab=SLP}
C {devices/lab_wire.sym} 2630 620 0 1 {name=p12 sig_type=std_logic lab=BT}
C {devices/lab_wire.sym} 2630 660 0 1 {name=p13 sig_type=std_logic lab=B1}
C {devices/lab_wire.sym} 2630 640 0 1 {name=p14 sig_type=std_logic lab=B0}
C {devices/lab_wire.sym} 2630 680 0 1 {name=p15 sig_type=std_logic lab=B2}
C {devices/lab_wire.sym} 2630 700 0 1 {name=p16 sig_type=std_logic lab=B3}
C {devices/lab_wire.sym} 2630 720 0 1 {name=p22 sig_type=std_logic lab=B4}
C {devices/lab_wire.sym} 2630 740 0 1 {name=p23 sig_type=std_logic lab=B5}
C {devices/lab_wire.sym} 2630 760 0 1 {name=p24 sig_type=std_logic lab=B6}
C {devices/lab_wire.sym} 2630 780 0 1 {name=p25 sig_type=std_logic lab=B7}
C {devices/ipin.sym} 1220 970 0 0 {name=p27 lab=SWDRN1}
C {devices/ipin.sym} 1220 820 0 0 {name=p28 lab=SWBRN1}
C {devices/ipin.sym} 1220 840 0 0 {name=p29 lab=SWBRN2}
C {devices/ipin.sym} 1220 870 0 0 {name=p30 lab=SWCAP1}
C {devices/ipin.sym} 1220 890 0 0 {name=p31 lab=SWCAP2}
C {devices/ipin.sym} 1220 920 0 0 {name=p32 lab=SWBGR1}
C {devices/ipin.sym} 1220 940 0 0 {name=p33 lab=SWBGR2}
C {devices/ipin.sym} 1220 990 0 0 {name=p34 lab=SWDRN2}
C {devices/lab_wire.sym} 1410 1280 0 0 {name=p35 sig_type=std_logic lab=VSS}
C {LELO_TORD_SKY130A/dac_v4.sym} 1410 670 0 0 {name=x1}
C {LELO_TORD_SKY130A/dac_v4.sym} 2470 670 0 1 {name=x2}
