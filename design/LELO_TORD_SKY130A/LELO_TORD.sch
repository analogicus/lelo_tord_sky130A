v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {Shift-I          Insert new component
Shift-Z         Zoom in
Ctrl-Z           Zoom out
R                 Rotate
F                 Full view

Manual: https://xschem.sourceforge.io/stefan/xschem_man/xschem_man.pdf
} -560 610 0 0 0.6 0.6 {}
C {cborder/border_s.sym} 390 390 0 0 {
user="Tord Olsen Sætermo"
company="NTNU"}
C {devices/ipin.sym} -650 -400 0 0 {name=p1 lab=VDD_1V8}
C {devices/ipin.sym} -640 400 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} -620 0 0 0 {name=p3 lab=PWRUP_1V8}
