v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 300 -510 320 -510 {lab=DRAINCAPS}
N 300 -530 300 -510 {lab=DRAINCAPS}
N 300 -550 300 -530 {lab=DRAINCAPS}
N 300 -550 320 -550 {lab=DRAINCAPS}
N 300 -570 300 -550 {lab=DRAINCAPS}
N 300 -570 320 -570 {lab=DRAINCAPS}
N 300 -590 300 -570 {lab=DRAINCAPS}
N 280 -590 320 -590 {lab=DRAINCAPS}
N 300 -530 320 -530 {lab=DRAINCAPS}
N 280 -490 320 -490 {lab=VSS}
N 280 -850 320 -850 {lab=VDD}
N 280 -830 320 -830 {lab=CTRL}
N 280 -810 320 -810 {lab=#net1}
N 280 -790 320 -790 {lab=#net2}
N 280 -770 320 -770 {lab=#net3}
N 280 -750 320 -750 {lab=#net4}
N 280 -730 320 -730 {lab=#net5}
N 280 -710 320 -710 {lab=SEL_BRANCH1}
N 280 -690 320 -690 {lab=SEL_BRANCH2}
N 280 -670 320 -670 {lab=SEL_CAP1}
N 280 -650 320 -650 {lab=SEL_CAP2}
N 280 -630 320 -630 {lab=SWREF}
N 300 -630 300 -610 {lab=SWREF}
N 940 -730 940 -680 {lab=#net6}
N 940 -680 1120 -680 {lab=#net6}
N 620 -850 790 -850 {lab=#net7}
N 940 -660 940 -610 {lab=#net8}
N 940 -660 1120 -660 {lab=#net8}
N 990 -620 990 -490 {lab=#net9}
N 620 -490 990 -490 {lab=#net9}
N 990 -620 1120 -620 {lab=#net9}
N 950 -820 990 -820 {lab=#net10}
N 990 -820 990 -720 {lab=#net10}
N 990 -720 1120 -720 {lab=#net10}
N 440 -940 1270 -940 {lab=#net11}
N 1270 -940 1270 -760 {lab=#net11}
N 440 -920 1290 -920 {lab=#net12}
N 1290 -920 1290 -750 {lab=#net12}
N 280 -950 320 -950 {lab=#net13}
N 280 -930 320 -930 {lab=#net14}
N 280 -910 320 -910 {lab=#net15}
N 300 -610 320 -610 {lab=SWREF}
N 620 -610 940 -610 {lab=#net8}
N 620 -730 940 -730 {lab=#net6}
N 1130 -700 1170 -700 {lab=#net16}
N 1130 -640 1170 -640 {lab=#net17}
N 1270 -780 1270 -740 {lab=#net11}
N 1290 -770 1290 -730 {lab=#net12}
N 1230 -580 1230 -540 {lab=#net18}
N 1250 -590 1250 -550 {lab=#net19}
N 1270 -600 1270 -560 {lab=#net20}
N 1390 -670 1430 -670 {lab=#net21}
N 750 -870 790 -870 {lab=#net22}
N 750 -770 790 -770 {lab=#net23}
N 750 -830 790 -830 {lab=#net24}
N 750 -810 790 -810 {lab=#net25}
N 750 -790 790 -790 {lab=#net26}
N 1230 -800 1230 -760 {lab=#net27}
N 1250 -790 1250 -750 {lab=#net28}
C {LELO_TORD_SKY130A/bias.sym} 380 -930 0 0 {name=x1}
C {LELO_TORD_SKY130A/cmp.sym} 1270 -670 0 0 {name=x2}
C {LELO_TORD_SKY130A/bgr_core.sym} 470 -670 0 0 {name=x3}
C {LELO_TORD_SKY130A/tmp_core.sym} 870 -820 0 0 {name=x4}
C {devices/ipin.sym} 280 -850 0 0 {name=p1 lab=VDD}
C {devices/ipin.sym} 280 -490 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 280 -830 0 0 {name=p3 lab=CTRL}
C {devices/ipin.sym} 280 -590 0 0 {name=p4 lab=DRAINCAPS}
C {devices/ipin.sym} 280 -630 0 0 {name=p5 lab=SWREF}
C {devices/ipin.sym} 280 -650 0 0 {name=p6 lab=SEL_CAP2}
C {devices/ipin.sym} 280 -670 0 0 {name=p7 lab=SEL_CAP1}
C {devices/ipin.sym} 280 -710 0 0 {name=p8 lab=SEL_BRANCH1}
C {devices/ipin.sym} 280 -690 0 0 {name=p9 lab=SEL_BRANCH2}
