v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 1060 560 1100 560 {lab=B0}
N 1060 680 1100 680 {lab=B6}
N 1060 660 1100 660 {lab=B5}
N 1060 640 1100 640 {lab=B4}
N 1060 620 1100 620 {lab=B3}
N 1060 600 1100 600 {lab=B2}
N 1060 500 1100 500 {lab=VDD}
N 1060 520 1100 520 {lab=SLP}
N 1060 580 1100 580 {lab=B1}
N 1060 740 1100 740 {lab=B9}
N 1060 720 1100 720 {lab=B8}
N 1060 700 1100 700 {lab=B7}
N 1820 480 1820 540 {lab=IOUT}
N 2260 1020 2260 1080 {lab=V2C}
N 2220 980 2240 980 {lab=VSS}
N 2220 980 2220 1180 {lab=VSS}
N 1470 1180 2760 1180 {lab=VSS}
N 1820 1140 1820 1180 {lab=VSS}
N 1760 1110 1780 1110 {lab=VSS}
N 1760 1110 1760 1180 {lab=VSS}
N 2260 1140 2260 1180 {lab=VSS}
N 2300 1110 2320 1110 {lab=VSS}
N 2320 1110 2320 1180 {lab=VSS}
N 2260 640 2260 790 {lab=V2A}
N 1960 800 2000 800 {lab=V1B}
N 1740 620 1780 620 {lab=VDD}
N 1740 590 1780 590 {lab=SWBRN1}
N 2310 620 2350 620 {lab=VSS}
N 2180 620 2220 620 {lab=VDD}
N 2180 590 2220 590 {lab=SWBRN2}
N 2440 1010 2440 1180 {lab=VSS}
N 2440 800 2440 940 {lab=V2}
N 2260 480 2260 540 {lab=IOUT}
N 1820 640 1820 790 {lab=V1A}
N 1640 1010 1640 1180 {lab=VSS}
N 1820 810 1820 1080 {lab=V1A}
N 2000 800 2000 940 {lab=V1B}
N 2000 1020 2000 1060 {lab=VR1}
N 2000 1140 2000 1180 {lab=VSS}
N 1960 980 1980 980 {lab=VSS}
N 1960 980 1960 1180 {lab=VSS}
N 1960 1100 1980 1100 {lab=VSS}
N 2080 1020 2080 1060 {lab=VR2}
N 2100 980 2120 980 {lab=VSS}
N 2120 980 2120 1180 {lab=VSS}
N 2100 1100 2120 1100 {lab=VSS}
N 2080 1140 2080 1180 {lab=VSS}
N 2380 850 2380 890 {lab=VSS}
N 2380 720 2380 760 {lab=VDD}
N 2350 720 2350 760 {lab=SWCAP2}
N 2400 800 2440 800 {lab=V2}
N 1640 800 1640 940 {lab=V1}
N 1700 850 1700 890 {lab=VSS}
N 1700 720 1700 760 {lab=VDD}
N 1730 720 1730 760 {lab=SWCAP1}
N 2260 810 2260 940 {lab=V2A}
N 1810 790 1810 810 {lab=V1A}
N 1810 810 1830 810 {lab=V1A}
N 1830 790 1830 810 {lab=V1A}
N 1810 790 1830 790 {lab=V1A}
N 2250 790 2250 810 {lab=V2A}
N 2250 810 2270 810 {lab=V2A}
N 2270 790 2270 810 {lab=V2A}
N 2250 790 2270 790 {lab=V2A}
N 1940 850 1940 890 {lab=VSS}
N 1940 720 1940 760 {lab=VDD}
N 1910 720 1910 760 {lab=SWBGR1}
N 2140 850 2140 890 {lab=VSS}
N 2140 720 2140 760 {lab=VDD}
N 2170 720 2170 760 {lab=SWBGR2}
N 2080 800 2120 800 {lab=V2B}
N 2080 800 2080 940 {lab=V2B}
N 1870 620 1910 620 {lab=VSS}
N 2560 800 2560 940 {lab=V2}
N 2560 1000 2560 1180 {lab=VSS}
N 1480 800 1680 800 {lab=V1}
N 1520 800 1520 940 {lab=V1}
N 1520 1000 1520 1180 {lab=VSS}
N 1440 970 1480 970 {lab=SWDRN1}
N 1520 970 1560 970 {lab=VSS}
N 1560 970 1560 1020 {lab=VSS}
N 1520 1020 1560 1020 {lab=VSS}
N 2520 970 2560 970 {lab=VSS}
N 2520 970 2520 1020 {lab=VSS}
N 2520 1020 2560 1020 {lab=VSS}
N 2600 970 2640 970 {lab=SWDRN2}
N 1780 800 1810 800 {lab=V1A}
N 1830 800 1860 800 {lab=V1A}
N 2220 800 2250 800 {lab=V2A}
N 2270 800 2300 800 {lab=V2A}
N 2560 800 2600 800 {lab=V2}
N 2560 780 2600 780 {lab=V1}
N 2440 800 2560 800 {lab=V2}
N 1060 920 1100 920 {lab=SWBRN1}
N 1060 940 1100 940 {lab=SWBRN2}
N 1060 990 1100 990 {lab=SWCAP1}
N 1060 1010 1100 1010 {lab=SWCAP2}
N 1060 1060 1100 1060 {lab=SWBGR1}
N 1060 1080 1100 1080 {lab=SWBGR2}
N 1060 1110 1100 1110 {lab=SWDRN1}
N 1060 1130 1100 1130 {lab=SWDRN2}
N 2810 620 2850 620 {lab=VSS}
N 2680 620 2720 620 {lab=VDD}
N 2680 590 2720 590 {lab=SWBRN3}
N 2940 1010 2940 1180 {lab=VSS}
N 3080 1000 3080 1180 {lab=VSS}
N 3080 800 3080 940 {lab=VOUT}
N 3040 970 3080 970 {lab=VSS}
N 3040 970 3040 1020 {lab=VSS}
N 3040 1020 3080 1020 {lab=VSS}
N 2940 1180 3080 1180 {lab=VSS}
N 3120 970 3160 970 {lab=SWDRN3}
N 2760 480 2760 540 {lab=IOUT}
N 2760 640 2760 940 {lab=VREF}
N 2720 980 2740 980 {lab=VSS}
N 2720 980 2720 1180 {lab=VSS}
N 2760 1020 2760 1180 {lab=VSS}
N 2760 1180 2940 1180 {lab=VSS}
N 2940 800 2940 940 {lab=VOUT}
N 2880 850 2880 890 {lab=VSS}
N 2880 720 2880 760 {lab=VDD}
N 2850 720 2850 760 {lab=SWCAP3}
N 2900 800 2940 800 {lab=VOUT}
N 2760 800 2800 800 {lab=VREF}
N 2940 800 3080 800 {lab=VOUT}
N 3080 800 3120 800 {lab=VOUT}
N 1060 1150 1100 1150 {lab=SWDRN3}
N 1060 1030 1100 1030 {lab=SWCAP3}
N 1060 960 1100 960 {lab=SWBRN3}
N 1060 820 1100 820 {lab=B13}
N 1060 800 1100 800 {lab=B12}
N 1060 780 1100 780 {lab=B11}
N 1060 760 1100 760 {lab=B10}
N 1060 880 1100 880 {lab=VSS}
N 1060 860 1100 860 {lab=B15}
N 1060 840 1100 840 {lab=B14}
N 1060 350 1100 350 {lab=V2}
N 1060 370 1100 370 {lab=V1}
N 1400 330 1440 330 {lab=CMP_ASYNC}
N 1060 430 1100 430 {lab=VSS}
N 1060 330 1100 330 {lab=VDD}
N 1400 500 1440 500 {lab=IOUT}
N 1060 540 1100 540 {lab=SLP_N}
N 1310 1030 1350 1030 {lab=SLP_N}
N 1270 990 1310 990 {lab=VDD}
N 1270 1070 1310 1070 {lab=VSS}
N 1190 1030 1230 1030 {lab=SLP}
N 1060 390 1100 390 {lab=SLP}
N 1060 410 1100 410 {lab=SLP_N}
C {devices/ipin.sym} 1060 580 0 0 {name=p17 lab=B1}
C {devices/ipin.sym} 1060 600 0 0 {name=p18 lab=B2}
C {devices/ipin.sym} 1060 620 0 0 {name=p19 lab=B3}
C {devices/ipin.sym} 1060 640 0 0 {name=p20 lab=B4}
C {devices/ipin.sym} 1060 880 0 0 {name=p1 lab=VSS}
C {devices/ipin.sym} 1060 500 0 0 {name=p2 lab=VDD}
C {devices/ipin.sym} 1060 520 0 0 {name=p3 lab=SLP}
C {devices/ipin.sym} 1060 560 0 0 {name=p4 lab=B0}
C {devices/ipin.sym} 1060 660 0 0 {name=p5 lab=B5}
C {devices/ipin.sym} 1060 680 0 0 {name=p6 lab=B6}
C {devices/ipin.sym} 1060 700 0 0 {name=p8 lab=B7}
C {sky130_fd_pr/pnp_05v5.sym} 1800 1110 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 2280 1110 0 1 {name=Q2[7:0]
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1820 530 3 1 {name=x3}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2260 530 3 1 {name=x4}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 2440 1000 0 1 {name=x16[9:0]
}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 1640 1000 0 0 {name=x10[9:0]
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2290 800 0 0 {name=x8}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1790 800 0 1 {name=x5}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1850 800 0 0 {name=x6}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2230 800 0 1 {name=x7}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1480 970 0 0 {name=x9}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 2600 970 0 1 {name=x17}
C {devices/lab_wire.sym} 1700 880 0 0 {name=p44 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1700 750 0 0 {name=p45 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 590 0 0 {name=p46 sig_type=std_logic lab=SWBRN1}
C {devices/lab_wire.sym} 1770 620 0 0 {name=p47 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1880 620 0 1 {name=p48 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1940 750 0 1 {name=p49 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 880 0 1 {name=p50 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1730 750 0 1 {name=p51 sig_type=std_logic lab=SWCAP1}
C {devices/lab_wire.sym} 1910 750 0 0 {name=p52 sig_type=std_logic lab=SWBGR1}
C {devices/lab_wire.sym} 2170 750 0 1 {name=p53 sig_type=std_logic lab=SWBGR2}
C {devices/lab_wire.sym} 2350 750 0 0 {name=p55 sig_type=std_logic lab=SWCAP2}
C {devices/lab_wire.sym} 2140 750 0 0 {name=p56 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2380 750 0 1 {name=p57 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2140 880 0 0 {name=p58 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2380 880 0 1 {name=p59 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2320 620 0 1 {name=p60 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2210 590 0 0 {name=p61 sig_type=std_logic lab=SWBRN2}
C {devices/lab_wire.sym} 2210 620 0 0 {name=p62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 970 0 0 {name=p64 sig_type=std_logic lab=SWDRN1}
C {devices/lab_wire.sym} 2610 970 0 1 {name=p65 sig_type=std_logic lab=SWDRN2}
C {devices/lab_wire.sym} 1830 810 2 0 {name=p66 sig_type=std_logic lab=V1A}
C {devices/lab_wire.sym} 2000 810 2 0 {name=p67 sig_type=std_logic lab=V1B}
C {devices/lab_wire.sym} 2080 810 2 1 {name=p68 sig_type=std_logic lab=V2B}
C {devices/lab_wire.sym} 2250 810 2 1 {name=p69 sig_type=std_logic lab=V2A}
C {devices/lab_wire.sym} 2260 1060 0 0 {name=p70 sig_type=std_logic lab=V2C}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 2080 1060 3 1 {name=x14[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 2000 1060 1 0 {name=x12[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 2260 1020 1 1 {name=x15[1:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 2000 940 1 0 {name=x11[1:0] }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 2080 940 3 1 {name=x13[1:0]}
C {devices/lab_pin.sym} 1480 800 0 0 {name=p75 sig_type=std_logic lab=V1}
C {devices/lab_wire.sym} 2000 1050 0 0 {name=p71 sig_type=std_logic lab=VR1}
C {devices/lab_wire.sym} 2080 1050 0 1 {name=p80 sig_type=std_logic lab=VR2}
C {devices/opin.sym} 2600 800 0 0 {name=p21 lab=V2}
C {devices/opin.sym} 2600 780 2 1 {name=p26 lab=V1}
C {devices/ipin.sym} 1060 1110 0 0 {name=p27 lab=SWDRN1}
C {devices/ipin.sym} 1060 920 0 0 {name=p28 lab=SWBRN1}
C {devices/ipin.sym} 1060 940 0 0 {name=p29 lab=SWBRN2}
C {devices/ipin.sym} 1060 990 0 0 {name=p30 lab=SWCAP1}
C {devices/ipin.sym} 1060 1010 0 0 {name=p31 lab=SWCAP2}
C {devices/ipin.sym} 1060 1060 0 0 {name=p32 lab=SWBGR1}
C {devices/ipin.sym} 1060 1080 0 0 {name=p33 lab=SWBGR2}
C {devices/ipin.sym} 1060 1130 0 0 {name=p34 lab=SWDRN2}
C {devices/lab_wire.sym} 1510 1180 0 0 {name=p35 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1410 500 0 1 {name=p12 sig_type=std_logic lab=IOUT}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2760 530 3 1 {name=x18}
C {devices/lab_wire.sym} 2820 620 0 1 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2710 590 0 0 {name=p16 sig_type=std_logic lab=SWBRN3}
C {devices/lab_wire.sym} 2710 620 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 2940 1000 0 1 {name=x21[11:0]}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 3120 970 0 1 {name=x22 }
C {devices/lab_wire.sym} 3140 970 0 1 {name=p23 sig_type=std_logic lab=SWDRN3}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 2760 940 1 0 {name=x20[1:0]}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2790 800 0 0 {name=x19}
C {devices/lab_wire.sym} 2850 750 0 0 {name=p24 sig_type=std_logic lab=SWCAP3}
C {devices/lab_wire.sym} 2880 750 0 1 {name=p25 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2880 880 0 1 {name=p36 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 3120 800 2 1 {name=p37 lab=VOUT}
C {devices/lab_wire.sym} 2760 810 0 0 {name=p38 sig_type=std_logic lab=VREF}
C {devices/ipin.sym} 1060 1150 0 0 {name=p39 lab=SWDRN3}
C {devices/ipin.sym} 1060 1030 0 0 {name=p40 lab=SWCAP3}
C {devices/ipin.sym} 1060 960 0 0 {name=p42 lab=SWBRN3}
C {LELO_TORD_SKY130A/dac_v4.sym} 1250 690 0 0 {name=x1}
C {devices/ipin.sym} 1060 720 0 0 {name=p54 lab=B8}
C {devices/ipin.sym} 1060 740 0 0 {name=p63 lab=B9}
C {devices/ipin.sym} 1060 760 0 0 {name=p72 lab=B10}
C {devices/ipin.sym} 1060 780 0 0 {name=p73 lab=B11}
C {devices/ipin.sym} 1060 800 0 0 {name=p74 lab=B12}
C {devices/ipin.sym} 1060 820 0 0 {name=p76 lab=B13}
C {devices/ipin.sym} 1060 840 0 0 {name=p77 lab=B14}
C {devices/ipin.sym} 1060 860 0 0 {name=p7 lab=B15}
C {devices/lab_wire.sym} 1090 330 0 0 {name=p78 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1090 370 0 0 {name=p79 sig_type=std_logic lab=V1}
C {devices/lab_wire.sym} 1090 350 0 0 {name=p81 sig_type=std_logic lab=V2}
C {devices/lab_wire.sym} 1090 430 0 0 {name=p82 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 1440 330 2 1 {name=p83 lab=CMP_ASYNC}
C {LELO_TORD_SKY130A/cmp.sym} 1250 380 0 0 {name=x2}
C {devices/lab_wire.sym} 1820 500 0 1 {name=p9 sig_type=std_logic lab=IOUT}
C {devices/lab_wire.sym} 2260 500 0 1 {name=p10 sig_type=std_logic lab=IOUT}
C {devices/lab_wire.sym} 2760 500 0 1 {name=p11 sig_type=std_logic lab=IOUT}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 1230 1030 0 0 {name=x10 }
C {devices/lab_wire.sym} 1220 1030 0 0 {name=p14 sig_type=std_logic lab=SLP}
C {devices/lab_wire.sym} 1320 1030 0 1 {name=p41 sig_type=std_logic lab=SLP_N}
C {devices/lab_wire.sym} 1280 990 0 1 {name=p43 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1280 1070 2 0 {name=p84 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1060 540 0 0 {name=p13 sig_type=std_logic lab=SLP_N}
C {devices/lab_wire.sym} 1090 410 0 0 {name=p85 sig_type=std_logic lab=SLP_N}
C {devices/lab_wire.sym} 1090 390 0 0 {name=p86 sig_type=std_logic lab=SLP}
